# Keil uVision project Astra_pwer_controller.uvprojx, settings and files
target MDR1986VK214 (6160000::V6.16::ARMCLANG)
  device: MDR1986VK214 Milandr
  pack: Milandr.MDR1986VExx.2.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Astra_pwer_controller +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-unused-parameter
  c include: .\Src\Sys
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ./Src/App/: main.c
  group System
    ./Src/Sys/: board.h
software components: CMSIS:CORE 5.4.0, Board Support:BoardDefs 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:UseFuncs 2.0
